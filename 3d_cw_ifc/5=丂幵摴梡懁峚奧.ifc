Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: プロジェクト番号
Time: 2019-09-30T16:10:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 30 16:10:58 2019 * Host: teshi * Database: C:\Users\teshi\AppData\Local\Temp\{BD793E6E-BD2B-4211-96E4-9B85AE57E1D1}\ifc * Database version: 5507 * Database creation date: Mon Sep 30 16:10:55 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 30 16:10:57 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 30 16:10:57 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, プロジェクト番号
LongName: プロジェクト名; Phase: プロジェクト ステータス

# IfcSite, Default
RefLatitude: 35, 41, 22, 154846; RefLongitude: 139, 41, 30, 161132; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 2
LongName: レベル 2; Elevation: 3000 mm

# IfcBuildingElementProxy: ⑤車道用用側溝蓋, ⑤車道用用側溝蓋:⑤車道用用側溝蓋:367058
In: レベル 2
Pset_BuildingElementProxyCommon - Reference: ⑤車道用用側溝蓋
