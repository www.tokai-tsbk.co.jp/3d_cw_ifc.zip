Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: プロジェクト番号
Time: 2019-09-30T16:16:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 30 16:16:11 2019 * Host: teshi * Database: C:\Users\teshi\AppData\Local\Temp\{5EB24FF6-20B6-4BEC-8E40-4F70A1851222}\ifc * Database version: 5507 * Database creation date: Mon Sep 30 16:16:08 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 30 16:16:09 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 30 16:16:09 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, プロジェクト番号
LongName: プロジェクト名; Phase: プロジェクト ステータス

# IfcSite, Default
RefLatitude: 35, 41, 22, 154846; RefLongitude: 139, 41, 30, 161132; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 2
LongName: レベル 2; Elevation: 3000 mm

# IfcBuildingElementProxy: ⑤カセットウォール本体300×700, ⑤カセットウォール本体300×700:⑤カセットウォール本体300×700:367074
In: レベル 2
Pset_BuildingElementProxyCommon - Reference: ⑤カセットウォール本体300×700
